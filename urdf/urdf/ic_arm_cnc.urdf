Commit message: feat: update urdf direction

File: urdf/urdf/ic_arm_cnc.urdf (robot description, URDF)
Before this commit: robot ic_arm_cnc, 7 links, 6 joints
Joints:
- joint j1: axis 0 0 -1 -> 0 0 1
- joint j4: axis 0 0 -1 -> 0 0 1
- joint j6: axis 0 0 -1 -> 0 0 1
